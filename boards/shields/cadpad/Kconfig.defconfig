## boards/shields/cadpad/Kconfig.defconfig
```kconfig
if SHIELD_CADPAD

config ZMK_KEYBOARD_NAME
    default "cadpad"

endif # SHIELD_CADPAD
```
